# IAR project MQTT.ewp, settings and files
configuration MQTT (ARM, debug)
  General.OGChipSelectEditMenu: STM32F107VC ST STM32F107VC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F107xC
  ICCARM.CCIncludePath2: ../Inc; ../Middlewares/Third_Party/LwIP/src/include; ../Middlewares/Third_Party/LwIP/system; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/LwIP/src/include/netif/ppp; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Middlewares/Third_Party/LwIP/src/include/lwip; ../Middlewares/Third_Party/LwIP/src/include/lwip/apps; ../Middlewares/Third_Party/LwIP/src/include/lwip/priv; ../Middlewares/Third_Party/LwIP/src/include/lwip/prot; ../Middlewares/Third_Party/LwIP/src/include/netif; ../Middlewares/Third_Party/LwIP/src/include/posix; ../Middlewares/Third_Party/LwIP/src/include/posix/sys; ../Middlewares/Third_Party/LwIP/system/arch; ../Drivers/CMSIS/Include; ..\Middlewares\Third_Party\LwIP\src\include\lwip\apps; ..\Middlewares\Third_Party\LwIP\src\apps\ping; ..\..\..\swadha-common; ..\..\..\hvac-common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MQTT_new.hex
  ILINK.IlinkOutputFile: MQTT.out
  ILINK.IlinkIcfFile: stm32f107xc_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f107xc.s
  group Application/User
    ../Src/: ADC.c Algo.c Auto_Algo.c cjson_packet.c DataStructure.c Drive_Communication.c ethernetif.c Flash_if.c FRAM.c glcd.c Keypad_Driver.c lwip.c lwip_mqtt.c main.c mbcrc.c Menu.c modbus_master.c ModbusProcess.c multi-uart-handler.c parson.c Retrofit.c rs485transceiver.c stm32f1xx_hal_msp.c stm32f1xx_it.c TCPServer.c TFTP_FlashConf.c tftp_parse.c Timer.c uart-cfg.c UV.c vav-communication.c vav-data.c
    ../../../swadha-common/byte-stuffing/: byte-stuffing.c
    ../../../swadha-common/circular-buffer/: circular-buffer.c
    ../../../swadha-common/crc/: crc.c
    ../../../swadha-common/general/: general.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../Middlewares/Third_Party/LwIP/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../Middlewares/Third_Party/LwIP/src/netif/: ethernet.c lowpan6.c slipif.c
    ../Middlewares/Third_Party/LwIP/src/apps/tftp/: tftp_server.c
  group Middlewares/MQTT
    ../Middlewares/Third_Party/LwIP/src/apps/mqtt/: mqtt.c
